# Keil uVision project STM32F7508-DK.uvprojx, settings and files
target STM32F7508-DK (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F750N8Hx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x800FFFF)  CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F7508-DK +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F750xx
  c include: ../Core/Inc;  ../TouchGFX/App;  ../TouchGFX/target/generated;  ../TouchGFX/target;  ../Drivers/STM32F7xx_HAL_Driver/Inc;  ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;  ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;  ../Drivers/CMSIS/Include;  ../Drivers/BSP/Components/Common;  ../Drivers/BSP/STM32F7508-Discovery; ../middlewares/st/touchgfx/framework/include; ../touchgfx/generated/fonts/include; ../touchgfx/generated/gui_generated/include; ../touchgfx/generated/images/include; ../touchgfx/generated/texts/include; ../touchgfx/gui/include
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\STM32F7508-DK.sct
  group Application/MDK-ARM
    ./: startup_stm32f750xx.s
    ./: bootloader.s
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/Core
    ../Core/Src/: user.c main.c freertos.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/BSP/STM32F7508-Discovery
    ../Drivers/BSP/STM32F7508-Discovery/: stm32f7508_discovery.c stm32f7508_discovery_sdram.c stm32f7508_discovery_ts.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ft5336/: ft5336.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group gui
    ../touchgfx/gui/src/control_screen/: controlpresenter.cpp controlview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/main_screen/: mainpresenter.cpp mainview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/start_screen/: startpresenter.cpp startview.cpp
    ../touchgfx/gui/src/status_screen/: statuspresenter.cpp statusview.cpp
  group generated
    ../touchgfx/generated/images/src/: a01_btn.cpp a04_led_g.cpp a05_led_r.cpp a06_led_w.cpp a09_sel.cpp b07_led_g.cpp b08_led_r.cpp b09_led_b.cpp background.cpp bitmapdatabase.cpp c01_btn.cpp c01_btn_selected.cpp clocks_backgrounds_clock_classic_background.cpp clocks_hands_clock_classic_hour_hand.cpp clocks_hands_clock_classic_minute_hand.cpp clocks_hands_clock_classic_second_hand.cpp f01start.cpp f02status.cpp f03control.cpp selectmenu_none.cpp
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_ytte08_ttf_12_4bpp_0.cpp font_ytte08_ttf_14_4bpp_0.cpp font_ytte08_ttf_14_4bpp_21.cpp font_ytte08_ttf_14_4bpp_22.cpp font_ytte08_ttf_14_4bpp_23.cpp font_ytte08_ttf_14_4bpp_24.cpp font_ytte08_ttf_14_4bpp_25.cpp font_ytte08_ttf_14_4bpp_26.cpp font_ytte08_ttf_24_4bpp_0.cpp font_ytte08_ttf_24_4bpp_24.cpp font_ytte08_ttf_24_4bpp_25.cpp fontcache.cpp generatedfont.cpp kerning_ytte08_ttf_12_4bpp.cpp kerning_ytte08_ttf_14_4bpp.cpp kerning_ytte08_ttf_24_4bpp.cpp table_ytte08_ttf_12_4bpp.cpp table_ytte08_ttf_14_4bpp.cpp table_ytte08_ttf_24_4bpp.cpp
    ../touchgfx/generated/images/src/__designer/: blue_buttons_round_small.cpp blue_buttons_round_small_pressed.cpp
    ../touchgfx/generated/gui_generated/src/control_screen/: controlviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/main_screen/: mainviewbase.cpp
    ../touchgfx/generated/gui_generated/src/start_screen/: startviewbase.cpp
    ../touchgfx/generated/gui_generated/src/status_screen/: statusviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 4.3.0
